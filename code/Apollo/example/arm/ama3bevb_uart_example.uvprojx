# Keil uVision project ama3bevb_uart_example.uvprojx, settings and files
target AMA3B1KK-KCR_Debug (ARM-ADS)
  device: AMA3B1KK-KCR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IROM(0xC000,0xF4000) IRAM1(0x10000000,0x5FFF0) CPUTYPE"(Cortex-M4")
  output: ama3bevb_uart_example +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO3_1024=1 APOLLO3_1024=1 APOLLO3_1024=1 APOLLO3_1024=1
  c include: ..\..\common;..\..\example\source;..\..\example\source\config;..\..\library;..\..\library\lowlevel;..\..\library\middleware;..\..\library\highlevel
  memory RVCT4: ROM 0x10000000 size 0x2fff8
  memory RVCT9: RAM 0x1002fff8 size 0x2fff8
  group common
    ../../common/: system_apollo3.c
    ../../cmsis/include/: core_cm4.h
  group source
    ../source/: main.c
    ../../: Readme.txt
    ./: startup_apollo3.s
target AMA3B1KK-KCR_Release (ARM-ADS)
  device: AMA3B1KK-KCR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: as above
  output: ama3bevb_uart_example +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO3_1024=1 APOLLO3_1024=1
  c include: as above
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x5fff0
target AMA3B1KK-KBR_Debug (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: as above
  output: ama3bevb_uart_example +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO3_1024=1 APOLLO3_1024=1 APOLLO3_1024=1 APOLLO3_1024=1
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x2fff8
  memory RVCT9: RAM 0x1002fff8 size 0x2fff8
target AMA3B1KK-KBR_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: as above
  output: ama3bevb_uart_example +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO3_1024=1 APOLLO3_1024=1
  c include: ..\..\common;..\..\example\source;..\..\example\source\config;..\..\library;..\..\library\lowlevel;..\..\library\middleware;..\..\library\highlevel;..\..\cmsis\include
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x5fff0
